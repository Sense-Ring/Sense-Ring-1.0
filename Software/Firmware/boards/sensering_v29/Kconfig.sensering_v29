## Software/Firmware/boards/sensering_v29/board.yml
```yaml
board:
  name: sensering_v29
  full_name: SenseRing v29
  vendor: sensering
  socs:
    - name: nrf52832
```
